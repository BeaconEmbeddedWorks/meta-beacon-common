PACKAGECONFIG = "dng gst pycamera"

