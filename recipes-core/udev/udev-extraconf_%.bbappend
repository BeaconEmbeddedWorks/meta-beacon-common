SRC_URI:remove = " file://blacklist.conf"
