SRCREV = "b937f3011a2c9ad70db6e0ae6752526e31f2e17d"
SRC_URI = "git://github.com/cpb-/spi-tools.git;protocol=https"
